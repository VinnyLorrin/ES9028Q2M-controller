<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\i2c_translator.ewp</path>
    </project>
    <batchBuild />
</workspace>
